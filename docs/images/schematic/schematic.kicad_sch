File: docs/images/schematic/schematic.kicad_sch (KiCad schematic)
At the start: 14 parts, among them SW1 SW_DIP_x08

Commit message: schematic, bd
Parts:
- renumbered SW1 to Keypad
